# Keil uVision project STC89C52RC.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: STC89C52RC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User
  group Startup
    ../Startup/: STARTUP.A51
  group User
    ../User/: main.c bsp_delay.c bsp_timer.c bsp_key.c
